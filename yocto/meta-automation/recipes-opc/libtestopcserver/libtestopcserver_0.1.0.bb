PR = "r8"

LIC_FILES_CHKSUM = "file://COPYING;md5=d32239bcb673463ab874e80d47fae504"
SRC_URI[md5sum] = "bf384f4350b6209550c5a1e68d8bece6"
SRC_URI[sha256sum] = "7a6158cdf5a9e2123ad83b2f3dd82145ff6ca77946bef644da4c257646354639"

require libtestopcserver.inc

