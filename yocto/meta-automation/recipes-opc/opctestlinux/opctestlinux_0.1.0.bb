PR = "r2"

LIC_FILES_CHKSUM = "file://COPYING;md5=d32239bcb673463ab874e80d47fae504"
SRC_URI[md5sum] = "7fc77c3b114c8ee769363bb790d4287e"
SRC_URI[sha256sum] = "2c3b49f99a0c6cd1f6a25ced973cb9d6d6423f6288300f7d89881c424e942ac3"

require opctestlinux.inc

