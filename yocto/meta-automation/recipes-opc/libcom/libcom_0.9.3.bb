PR = "r21"

LIC_FILES_CHKSUM = "file://COPYING;md5=d32239bcb673463ab874e80d47fae504"
SRC_URI[md5sum] = "7d15997b6b71b1ff2858edb025eb1979"
SRC_URI[sha256sum] = "962915f497ba5f915bf771e186bab0d76d8ddbf20b3ba46ad5b150a356b12b88"

require libcom.inc

